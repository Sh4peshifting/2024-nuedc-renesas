# Keil uVision project FSP_rtosprj.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.5.2.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FSP_rtosprj +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\ra\arm\CMSIS_5\CMSIS\Core\Include;.\ra\fsp\inc;.\ra\fsp\inc\api;.\ra\fsp\inc\instances;.\ra_cfg\fsp_cfg\bsp;.\ra_cfg\fsp_cfg;.\ra_gen;.\RTE\_Target_1;.\user_src;.\ra\aws\FreeRTOS\FreeRTOS\Source\include;.\ra_cfg\aws;.\ra\fsp\src\rm_freertos_port
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c led1_entry.c usartprocess_entry.c motion_entry.c hmi_entry.c working_entry.c interface_entry.c
  group user
    ./user_src/: dht11.c fire_alarm.c ic_detect.c rc522.c screen_uart.c ws2812.c motor.c user.c interface_driver.c
software components: Flex Software:RA Configuration 1.0.0
